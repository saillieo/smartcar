# Keil uVision project car.uvprojx, settings and files
target Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\STM32F10x_FWLib\inc;..\User;..\System\delay;..\System\sys;..\System\usart;..\Hardware\MPU6050;..\Hardware\MPU6050\eMPL;..\Hardware\PWM;..\Hardware\Motor;..\Hardware\Encoder;..\Hardware\Ultrasonic;..\Hardware\Timer;..\Hardware\Control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/usart/: usart.c
  group Hardware
    ../Hardware/MPU6050/: mpu6050.c mpuiic.c
    ../Hardware/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../Hardware/Control/: control.c
    ../Hardware/Encoder/: encoder.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/Motor/: motor.c
    ../Hardware/PWM/: pwm.c
    ../Hardware/Ultrasonic/: ultrasonic.c
    ../Hardware/Timer/: timer.c
